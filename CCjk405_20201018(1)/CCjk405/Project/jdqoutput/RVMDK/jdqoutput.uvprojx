# Keil uVision project jdqoutput.uvprojx, settings and files
target D405 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_Program +hex
  AfterMake: fromelf.exe --bin --strip=debug --output ./bin/STM32_Program.bin ./obj/STM32_Program.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS,USE_STM324xG_EVAL
  c misc: --c99
  c include: ..\..\..\;..\..\inc;..\..\BSP;..\..\uC-CPU;..\..\uC-CPU\ARM-Cortex-M3\Keil;..\..\uC-LIB;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\Keil;..\..\src;..\..\uCOS-II\Source;..\..\src;..\include\arch;..\..\driver\gpio;..\..\driver\uart;..\src;..\..\driver\rtc;..\..\driver\CAN;..\..\queue;..\..\driver\wdg;..\app;..\..\driver\i2c;..\..\J1939;..\common;..\bms;..\..\uCOS-II\Ports;..\screen;..\backproto;..\..\driver\adc;..\module;..\backproto\Wifi;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Driver\ethnet\STM32F4x7_ETH_Driver;..\..\fat_fs\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Driver\ethnet;..\..\Driver\store;..\..\Driver\mcp2515;..\device;..\..\Driver\sst26VF0xxB;..\..\LwIP;..\..\LwIP\arch;..\..\LwIP\lwip_app\lwip_comm;..\..\LwIP\lwip_app\tcp_client_demo;..\..\LwIP\ETHERNET;..\..\LwIP\MALLOC;..\..\LwIP\SYSTEM\delay;..\..\LwIP\SYSTEM\sys;..\..\Ethnet;..\..\LwIP\lwip-2_1_2\src;..\..\LwIP\lwip-2_1_2\src\netif;..\..\LwIP\lwip-2_1_2\src\include;..\..\LwIP\lwip-2_1_2\src\include\compat;..\..\LwIP\lwip-2_1_2\src\include\lwip;..\..\LwIP\lwip-2_1_2\src\include\lwip\apps;..\..\LwIP\lwip-2_1_2\src\include\lwip\priv;..\..\LwIP\lwip-2_1_2\src\include\lwip\prot;..\..\LwIP\lwip-2_1_2\src\include\netif;..\..\Driver\timer;..\..\Driver\flash;..\..\LwIP\lwip_comm;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;..\bms\heli
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../app/: Message.c main.c ChgData.c ModbusMaster.c RecordFat.c RelayOut.c Rf_Card.c secrt.c TaskCardReader.c TaskRealCheck.c Version.c BillingUnit.c memory.c MainCtrlUnit.c TaskAGunMainCtrl.c TaskBGunMainCtrl.c Net_Wifi.c MeaureGunTemperature.c SST_RecordFat.c TaskUSB.c Adebug.c Adc_Calc.c
    ../src/: stm32f4xx_it.c
  group BMS
    ../bms/: Bms.c GbtBmsProto.c PutianBmsProto.c PutianBms.c TaskAGunBmsComm.c TaskBGunBmsComm.c BmsCommUnit.c
    ../app/: BmsCan.c
    ../bms/heli/: HeLiBmsProto.c
  group BACKPROTO
    ../backproto/: Che_Dian.c TaskBackComm.c
    ../backproto/Wifi/: wifi_RAK415.c
  group SCREEN
    ../screen/: Hmi_Api.c Hmi_page.c TaskScreen.c Hmi_Api_II.c
  group MODULE
    ../module/: CdModel.c List.c An485Proto.c TaskCanModule.c PowerSplitt.c
  group DEVICE
    ../device/: TaskAcMeter.c TaskDcMeter.c TaskIsoCheck.c TaskWbIsoCheck.c
  group COMMON
    ../common/: common.c crc.c MD5.c
  group driver
    ../../driver/can/: can.c
    ../../driver/gpio/: gpio.c
    ../../driver/rtc/: rtc.c
    ../../driver/uart/: uart.c
    ../../driver/wdg/: wdg.c
    ../../driver/store/: fm24lc64.c
    ../../driver/adc/: adc.c
    ../../Driver/i2c/: stm324xg_eval.c stm324xg_eval_i2c_ee.c I2C_FLASH.c
    ../../Driver/mcp2515/: Low_level_MCP2515.c mcp2515.c
    ../../Driver/sst26VF0xxB/: Low_level_SST2xVF0xxB.c sst26VF0xxB.c SST_FLASH.c
    ../../Driver/ethnet/STM32F4x7_ETH_Driver/: stm32f4x7_eth.c
    ../../Driver/usbh/: usb_bsp.c usbh_usr.c
    ../../Driver/timer/: timer.c
    ../../Driver/flash/: flash_if_for_upgrade.c
    ../../Driver/rtc/: RTC_BKPDomain.c
  group lib
    ../../lib/: ucosii286_d.lib
  group queue
    ../../queue/: queue.c
software components: CMSIS:CORE 5.3.0
